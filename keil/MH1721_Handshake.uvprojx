# Keil uVision project MH1721_Handshake.uvprojx, settings and files
target Simulator (6160000::V6.16::ARMCLANG)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00004000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL
  output: MH1721_Handshake +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=4 v6LangP=4 wLevel=2
  c include: .\src
  library: MicroLIB
  scatter file: .\linker\sim.sct
  link misc: --entry=Reset_Handler
  group App
    ./src/: main.c handshake.c rsa.c board.c mh_rsa.c mh_misc.c mh_rand.c key.h startup_armcm3.S
